# Keil uVision project MUXadc.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: CM33 +hex
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L -c -d -e -s --output CM33.lst
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L --bin -o CM33.bin
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Lib\CMSIS\Device\StdPeriph_Driver\inc;..\Lib\CMSIS\Device\Include;..\Lib\CMSIS\Device\Source;..\Lib\CMSIS\Core\Include;..\Lib\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20200000 size 0x20000
  group startup
    ../Lib/CMSIS/Device/Source/ARM/: startup_ARMCM33.s
  group lib
    ../Lib/CMSIS/Device/StdPeriph_Driver/src/: STAR_adc.c STAR_dma.c STAR_dualtimer.c STAR_gpio.c STAR_i2c.c STAR_rcc.c STAR_retarget.c STAR_spi.c STAR_timer.c STAR_uart.c STAR_watchdog.c
    ../Lib/CMSIS/Device/Source/: system_ARMCM33.c
  group bsp
    ../Lib/BSP/: dma.c Dualtimer.c extint.c gpio_interrupt.c misc.c timer.c uart.c watchdog.c io_spi.c W5500.c
  group user
    ../User/: main.c GNSS.c
